# Keil uVision project tiget-lcd.uvprojx, settings and files
target LandTiger (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tiget-lcd
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./src/: main.c
  group adc
    ./src/adc/: ad_prober.c ad_prober.h probe_trig.c probe_trig.h
  group comm
    ./src/comm/: retarget.c retarget.h uart.c uart.h
  group gui
    ./src/gui/: chart.c chart.h gui.c gui.h gui_controller.c gui_controller.h
  group lcd
    ./src/lcd/: AsciiLib.c AsciiLib.h lcd.c lcd.h
  group osc
    ./src/osc/: config.c config.h osc.c osc.h
  group utils
    ./src/utils/: caster.c caster.h sci.c sci.h
software components: CMSIS:CORE 4.3.0, Board Support:Joystick 1.0.0, Device:GPIO 1.1, Device:PIN 1.0, Device:Startup 1.0.0
